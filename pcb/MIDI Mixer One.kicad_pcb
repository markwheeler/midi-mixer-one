# Repository markwheeler/midi-mixer-one

File README.md:

# MIDI Mixer One
MIDI Mixer One is a mixer-style USB MIDI controller built around Teensy.

[More info in the wiki](https://github.com/markwheeler/midi-mixer-one/wiki)

[Discussion thread on llllllll](https://llllllll.co/t/midi-mixer-one/35783)

Licensed under CC BY-NC-SA 4.0 (non-commercial use only).

## KiCad design pcb/MIDI Mixer One.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C6: 47uF; CP_Radial_D5.0mm_P2.00mm
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12, RV13, RV14, RV15, RV16, RV17, RV18, RV19, RV20, RV21, RV22, RV23, RV24, RV25, RV26, RV27, RV28, RV29, RV30, RV31, RV32, RV33, RV34, RV35, RV36, RV37, RV38, RV39, RV40, RV41: R_POT_US; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: Teensy-LC; Teensy30_31_32_LC
U2, U3, U4, U5, U6: 74HCT4051; DIP-16_W7.62mm

Connections:
+3V3: RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, RV13.3, RV14.3, RV15.3, RV16.3, RV17.3, RV18.3, RV19.3, RV20.3, RV21.3, RV22.3, RV23.3, RV24.3, RV25.3, RV26.3, RV27.3, RV28.3, RV29.3, RV30.3, RV31.3, RV32.3, RV33.3, RV34.3, RV35.3, RV36.3, RV37.3, RV38.3, RV39.3, RV40.3, RV41.3, U1.31
+5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, U1.33, U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.16 (VCC), U6.16 (VCC)
/A0: U1.21, U2.3 (A)
/A1: U1.22, U3.3 (A)
/A2: U1.23, U4.3 (A)
/A3: U1.24, U5.3 (A)
/A4: U1.25, U6.3 (A)
/A5: RV41.2, U1.26
/D0: SW10.1, U1.2
/D1: SW7.1, U1.3
/D2: SW4.1, U1.4
/D3: SW1.1, U1.5
/D4: SW11.1, U1.6
/D5: SW8.1, U1.7
/D6: SW5.1, U1.8
/D7: SW3.1, U1.9
/D8: SW6.1, U1.10
/D9: SW9.1, U1.11
/D10: SW12.1, U1.12
/D11: SW2.1, U1.13
/RV1: RV1.2, U2.12 (A3)
/RV2: RV2.2, U2.13 (A0)
/RV3: RV3.2, U2.14 (A1)
/RV4: RV4.2, U2.15 (A2)
/RV5: RV5.2, U2.1 (A4)
/RV6: RV6.2, U2.5 (A5)
/RV7: RV7.2, U2.4 (A7)
/RV8: RV8.2, U2.2 (A6)
/RV9: RV9.2, U3.14 (A1)
/RV10: RV10.2, U3.15 (A2)
/RV11: RV11.2, U3.12 (A3)
/RV12: RV12.2, U3.13 (A0)
/RV13: RV13.2, U3.4 (A7)
/RV14: RV14.2, U3.2 (A6)
/RV15: RV15.2, U3.1 (A4)
/RV16: RV16.2, U3.5 (A5)
/RV17: RV17.2, U4.12 (A3)
/RV18: RV18.2, U4.13 (A0)
/RV19: RV19.2, U4.14 (A1)
/RV20: RV20.2, U4.15 (A2)
/RV21: RV21.2, U4.5 (A5)
/RV22: RV22.2, U4.4 (A7)
/RV23: RV23.2, U4.2 (A6)
/RV24: RV24.2, U4.1 (A4)
/RV25: RV25.2, U5.13 (A0)
/RV26: RV26.2, U5.4 (A7)
/RV27: RV27.2, U5.5 (A5)
/RV28: RV28.2, U5.12 (A3)
/RV29: RV29.2, U5.14 (A1)
/RV30: RV30.2, U5.15 (A2)
/RV31: RV31.2, U5.2 (A6)
/RV32: RV32.2, U5.1 (A4)
/RV33: RV33.2, U6.12 (A3)
/RV34: RV34.2, U6.13 (A0)
/RV35: RV35.2, U6.14 (A1)
/RV36: RV36.2, U6.5 (A5)
/RV37: RV37.2, U6.4 (A7)
/RV38: RV38.2, U6.2 (A6)
/RV39: RV39.2, U6.1 (A4)
/RV40: RV40.2, U6.15 (A2)
/S0: U1.30, U2.11 (S0), U3.11 (S0), U4.11 (S0), U5.11 (S0), U6.11 (S0)
/S1: U1.29, U2.10 (S1), U3.10 (S1), U4.10 (S1), U5.10 (S1), U6.10 (S1)
/S2: U1.28, U2.9 (S2), U3.9 (S2), U4.9 (S2), U5.9 (S2), U6.9 (S2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, RV13.1, RV14.1, RV15.1, RV16.1, RV17.1, RV18.1, RV19.1, RV20.1, RV21.1, RV22.1, RV23.1, RV24.1, RV25.1, RV26.1, RV27.1, RV28.1, RV29.1, RV30.1, RV31.1, RV32.1, RV33.1, RV34.1, RV35.1, RV36.1, RV37.1, RV38.1, RV39.1, RV40.1, RV41.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, U1.1, U1.17, U1.32, U2.6 (~E), U2.7 (VEE), U2.8 (GND), U3.6 (~E), U3.7 (VEE), U3.8 (GND), U4.6 (~E), U4.7 (VEE), U4.8 (GND), U5.6 (~E), U5.7 (VEE), U5.8 (GND), U6.6 (~E), U6.7 (VEE), U6.8 (GND)

Board: 2 copper layers, 280.2 x 132.1 mm, 65 parts (0 on the bottom side), 64 nets.

## Commit log

2020-08-04 initial
2020-08-04 cleanup old versions
2020-08-04 cleanup kicad libs and cache files
2020-08-08 better pot reading across muxes, send all function, discard incoming midi
2020-08-10 removed REF text from silk screen
2020-08-14 git ignore
2020-08-16 formatting, param tweaks, pot res, all pots enabled
2020-08-20 tweaked pot reading using ResponsiveAnalogRead
2020-08-20 first draft custom
2020-08-20 new code for pots
2020-08-20 tidy
2020-08-20 delay and fps log
2020-08-20 enabled fps log
2020-08-21 sleep, optimizations, cleanup
2020-08-21 minor refactor into functions, tidy
2020-08-21 comment out fps logging
2020-08-21 removed countersinks from panels
2020-08-23 rename mix pot
2020-08-26 first pass midi remote script WIP
2020-08-26 formatting
2020-08-26 photos
2020-08-26 cue jump, better scrubbing
2020-08-27 key repeating for arrows
2020-08-27 rename vars, fix scrub under 0
2020-08-28 set_track_relative cleanup
2020-09-01 refactored key repeat and enabled for jumping cue points
2020-09-01 disconnect
2020-10-24 wip web config tool
2020-10-26 wip web config
2020-10-27 layout and style
2020-10-27 refactoring
2020-10-27 clean css
2020-10-28 defaults button etc
2020-10-30 big refactor
2020-10-30 ui generation etc
2020-10-30 minor refactor
2020-11-02 request sent callback. dummy response.
2020-11-02 start on unserializing
2020-11-03 events WIP
2020-11-04 serialize. ui hookup.
2020-11-05 switched to events, global channel, defaults
2020-11-05 start of sysex processing on teensy
2020-11-07 first draft sysex config saving on mm1
2020-11-08 v1.0.0 hex
2020-11-28 filter input and only update ports when need be
2020-11-28 code auto format
2020-11-28 remove dummy response button
2020-11-28 auto select on port change
2020-11-28 fix init, remove logs
2020-11-28 html validation fixes
2020-11-28 error string update
2020-11-29 global channel state fix
2020-11-29 firmware code cleanup
2020-11-29 added writeFailed callback
2020-11-29 fixed key selection bug
2020-11-29 readme
2020-11-29 web config screenshot
2020-11-29 image update
2020-11-29 image rename
2020-11-29 image
2020-11-29 remove hex
2021-04-22 added shift key, CC keys and totally new method for storing and sending config in less bits. formatting.
2021-04-22 fix for incompatibleProtocol message
2021-04-22 fix incompatibleProtocol
2021-04-25 new photo
2021-05-11 updated remote script for live 11
2024-01-10 adds toggle to switches.
